EXTRA_OECONF += "--without-gnome"
