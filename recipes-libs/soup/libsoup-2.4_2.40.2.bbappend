PR += "-without-gnome"

EXTRA_OECONF += "--without-gnome"
