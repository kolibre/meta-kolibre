DEPENDS += "soundtouch"

EXTRA_OECONF += "--disable-sdl"
