DEPENDS += "libsoup-2.4 pulseaudio"
